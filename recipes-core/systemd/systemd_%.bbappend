
PACKAGECONFIG += "networkd resolved"

