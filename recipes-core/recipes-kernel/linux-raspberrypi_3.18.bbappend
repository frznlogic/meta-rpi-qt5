SRC_URI_remove = "file://sl030raspberrypii2ckernel.patch"
