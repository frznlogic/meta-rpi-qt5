
SRC_URI_append = "file://0002-fix-build.patch"
